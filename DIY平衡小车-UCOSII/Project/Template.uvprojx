# Keil uVision project Template.uvprojx, settings and files
target Template (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\APP;..\CORE;..\HARDWARE\LED;..\HARDWARE\Systick;..\STM32_Lib\inc;..\UCOSII\CONFIG;..\UCOSII\CORE;..\UCOSII\PORT;..\APP\LED;..\APP\USART;..\APP\KEY;..\APP\Motor;..\APP\TIM-ENCODE;..\APP\TIM-PWM;..\APP\TIM-ENCODE;..\APP\SPI;..\APP\OLED
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CORE
    ../CORE/: startup_stm32f10x_hd.s core_cm3.c
  group APP
    ../APP/: main.c stm32f10x_it.c system_stm32f10x.c
    ../APP/LED/: bsp_led.c
    ../APP/USART/: bsp_usart.c
    ../APP/KEY/: bsp_key.c
    ../APP/Motor/: bsp_motor.c
    ../APP/TIM-PWM/: bsp_tim_pwm.c
    ../APP/TIM-ENCODE/: bsp_tim_encode.c
    ../APP/OLED/: oled.c
    ../APP/SPI/: bsp_spi.c
  group HARDWARE
    ../HARDWARE/Systick/: systick.c
  group STM32-Lib
    ../STM32_Lib/src/: stm32f10x_wwdg.c misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group UCOSII-CORE
    ../UCOSII/CORE/: os_tmr.c os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c
  group UCOSII-PORT
    ../UCOSII/PORT/: os_cpu_c.c os_cpu.h os_cpu_a.asm
  group UCOSII-CONFIG
    ../UCOSII/CONFIG/: includes.h os_cfg.h
